Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-16T08:56:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 16 08:56:13 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\26193da5-e530-45e2-a935-065519cc0a71\18abec6e-56d3-4b09-96df-4417a7138f27\ifc * Database version: 5507 * Database creation date: Wed Nov 16 08:56:12 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 16 08:56:13 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 16 08:56:13 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11733550_SER_APWM053_DOS-WLM1:59510053_SER_11733550_APWM053_DOS-WLM1, (2)
In: Default
Type - Material: z_Miele_Design_BRWS
Type - Pset_BuildingElementProxyCommon - Reference: 59510053_SER_11733550_APWM053_DOS-WLM1
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 59510053_SER_11733550_APWM053_DOS-WLM1
Material: z_Miele_Design_BRWS, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
